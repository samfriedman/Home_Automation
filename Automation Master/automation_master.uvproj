# Keil uVision project automation_master.uvproj, settings and files
target automation_master (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: automation_master
  AfterMake: fromelf --bin --output .\rvmdk\automation_master.bin .\rvmdk\automation_master.axf
  c flags: Optim=1
  c define: rvmdk PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0 UART_BUFFERED
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.0.1.11577;..\..\workspace
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: automation_master.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_TM4C129.s automation_master.c
    ../utilities/: nRF24L01.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.0.1.11577/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.0.1.11577/utils/: cmdline.c uartstdio.c ustdlib.c
