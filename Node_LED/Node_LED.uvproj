# Keil uVision project Node_LED.uvproj, settings and files
target Node_LED (ARM-ADS)
  device: LM4F232H5BB Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Node_LED
  AfterMake: fromelf --bin --output .\rvmdk\Node_LED.bin .\rvmdk\Node_LED.axf
  c flags: Optim=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RA3
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-1.0;..\..\workspace
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: Node_LED.sct
  link misc: --entry Reset_Handler
  group Source
    ./: Node_LED.c startup_rvmdk.S
  group Libraries
    C:/ti/TivaWare_C_Series-1.0/driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
  group Utilities
    ../utilities/: nRF24L01.c
