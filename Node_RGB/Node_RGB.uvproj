# Keil uVision project Node_RGB.uvproj, settings and files
target Node_RGB (ARM-ADS)
  device: LM4F232H5BB Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Node_RGB
  AfterMake: fromelf --bin --output .\rvmdk\Node_RGB.bin .\rvmdk\Node_RGB.axf
  c flags: Optim=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RA3
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-1.0;..;C:\ti\TivaWare_C_Series-1.0\examples\boards\ek-tm4c123gxl
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: Node_RGB.sct
  link misc: --entry Reset_Handler
  group Source
    ./: Node_RGB.c startup_rvmdk.S
  group Libraries
    C:/ti/TivaWare_C_Series-1.0/driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
  group Utilities
    ../utilities/: nRF24L01.c
  group TI_Drivers
    C:/ti/TivaWare_C_Series-1.0/examples/boards/ek-tm4c123gxl/drivers/: rgb.c
